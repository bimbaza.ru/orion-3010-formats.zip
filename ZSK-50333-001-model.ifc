Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:48+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-50333-001
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Оборудование благоустройства, ZSK-50333-001 Тематический игровой комплекс (Транспорт) «Полицейский автомобиль»
In: Площадка
Description: Оборудование благоустройства. Тематический игровой комплекс (Транспорт) «Полицейский автомобиль»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-50333-001; ModelReference: Тематический игровой комплекс (Транспорт) «Полицейский автомобиль»; ProductionYear: 2026; ArticleNumber: ZSK-50333-001
ORION_Изделие - Артикул: ZSK-50333-001; Артикул прежний: SD-50333-001; Наименование: Тематический игровой комплекс (Транспорт) «Полицейский автомобиль»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 7.6 x 5.8 м; Зона безопасности: 11.2 x 8.8 м; Высота свободного падения: 1.2 м; Возраст: для детей от 2 до 12 лет; Цена: 4 425 393 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/transport/3010; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Тематический игровой комплекс (Транспорт) «Полицейский автомобиль»; ADSK_Марка: ZSK-50333-001; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/transport/3010
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 12 лет; ZSK_Зона_безопасности: 11.2 x 8.8 м; ZSK_Высота_свободного_падения: 1.2 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-50333-001
Qto_ORION - Длина: 7600 mm; Ширина: 5800 mm; Высота: 0 mm
